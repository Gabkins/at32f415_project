# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F415RCT7_v2 ArteryTek -AT32F415RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415RCT7
  ICCARM.CCIncludePath2: lib\cmsis\cm4\core_support; lib\cmsis\cm4\device_support; lib\drivers\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: AT32F415xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: at32f415_int.c hardware.h Indication_M128i1x.cpp Indication_M128i1x.h IndicationBase.h IndicatorConfig.h Keys_M128i1x.h KeysBase.cpp KeysBase.h main.cpp Rtc_at32f415.h RtcBase.h StaticQueue.h SystemInit.cpp SystemInit.h Time.h xprintf.c xprintf.h
    lib/drivers/inc/: at32f415_pwc.h
    lib/cmsis/cm4/device_support/startup/iar/: startup_at32f415.s
    lib/cmsis/cm4/device_support/: system_at32f415.c
  group drivers
    lib/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
